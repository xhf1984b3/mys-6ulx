## drivers/char/twst/Kconfig
```kconfig
menu "TWST Project Driver"

config TWST_DI
        tristate "TWST DI Project support"
        default y
        help

endmenu
```
